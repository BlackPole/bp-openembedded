DESCRIPTION = "meta file for USB DVB drivers"

DEPENDS = "\
	blackpole-dvb-common-modules \
	blackpole-dvb-frontends \
	blackpole-dvb-usb-modules \
	blackpole-dvb-siano \
	blackpole-dvb-em28xx \
	"

PR = "r0"
