include nano.inc

PR = "${INC_PR}.0"

SRC_URI += "file://ncursesw.includedir.patch"
