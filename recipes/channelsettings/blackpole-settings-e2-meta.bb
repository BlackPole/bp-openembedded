DESCRIPTION = "meta file for settings - BlackPole"

DEPENDS = "\
	enigma2-plugin-settings-khavari-motor \
	"

PR = "r0"
